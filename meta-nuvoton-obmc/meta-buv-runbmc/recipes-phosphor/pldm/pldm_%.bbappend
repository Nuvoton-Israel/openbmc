EXTRA_OEMESON:append = " -Dtransport-implementation=af-mctp"
