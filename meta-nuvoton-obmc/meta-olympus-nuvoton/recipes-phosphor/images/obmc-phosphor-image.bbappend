OBMC_IMAGE_EXTRA_INSTALL:append = " vdm-test" 
