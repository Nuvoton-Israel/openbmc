# This will skip the 'buildpaths' QA check for the libtinyxml2-staticdev package
INSANE_SKIP:${PN}-staticdev += "buildpaths"