FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-transporthandler-fix-mac-address-type-error.patch"