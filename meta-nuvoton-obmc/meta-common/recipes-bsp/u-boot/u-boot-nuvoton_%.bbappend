FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append: = " file://u-boot-emmc.cfg"
