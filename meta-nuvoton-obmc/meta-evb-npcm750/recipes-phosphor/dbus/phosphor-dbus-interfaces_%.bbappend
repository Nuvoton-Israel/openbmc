FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Software-Add-CPLD-MCU-VersionPurpose.patch"
