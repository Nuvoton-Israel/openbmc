# The satellite BMC has no KVM/video path to export.
RDEPENDS:${PN}-system:remove:df-satellite = "obmc-ikvm"
