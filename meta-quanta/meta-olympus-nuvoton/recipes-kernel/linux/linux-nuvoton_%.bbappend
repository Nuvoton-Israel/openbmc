FILESEXTRAPATHS:prepend := "${THISDIR}/linux-nuvoton:"

SRC_URI += "file://olympus-nuvoton.cfg"
SRC_URI += "file://enable-v4l2.cfg"
