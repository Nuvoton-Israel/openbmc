
FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

#SRC_URI_append_olympus-nuvoton = " file://0002-meta-quanta-meta-olympus-nuvoton-phosphor-user-manag.patch \
#                      "
