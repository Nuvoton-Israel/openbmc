DEPENDS_append = " olympus-nuvoton-boot-error-native"
