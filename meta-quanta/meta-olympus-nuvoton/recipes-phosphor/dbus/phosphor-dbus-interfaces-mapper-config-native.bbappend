PHOSPHOR_MAPPER_SERVICE_append = " com.intel.crashdump"
PHOSPHOR_MAPPER_INTERFACE_append = " com.intel.crashdump"
