SRC_URI_olympus-nuvoton := "git://github.com/Nuvoton-Israel/pmci.git;protocol=ssh"
SRCREV_olympus-nuvoton := "448498b926276521e2f82050e55790b6fd842c19"