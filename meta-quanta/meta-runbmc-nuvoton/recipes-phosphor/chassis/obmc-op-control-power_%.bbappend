FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "e32e33784a1883ee4528b17617df14f3114b0f5e"

SRC_URI += "file://0001-meta-runbmc-nuvoton-op-pwrctl-enable-server-power-co.patch"
