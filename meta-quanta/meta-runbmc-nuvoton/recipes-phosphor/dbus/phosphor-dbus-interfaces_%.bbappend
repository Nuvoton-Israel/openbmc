FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-sensor-threshold-error-items.patch"
SRC_URI += "file://0001-set-watchdog-Interval-value-to-three-minutes.patch"
