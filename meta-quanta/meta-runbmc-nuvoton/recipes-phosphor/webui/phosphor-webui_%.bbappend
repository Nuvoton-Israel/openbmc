FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI += "file://0001-Move-to-new-associations-interface.patch"
SRC_URI += "file://0001-Fixed-cannot-show-warning-high-and-critical-high.patch"
SRC_URI += "file://0001-Modify-bios-update-confirm-dialogue.patch"
