FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-host-power-state-inconsisent-issue.patch"
