FILESEXTRAPATHS_prepend_runbmc-nuvoton := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-meta-quanta-meta-runbmc-nuvoton-add-support-for-runb.patch"
