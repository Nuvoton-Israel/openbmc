SRC_URI_buv-runbmc := "git://github.com/Nuvoton-Israel/pmci.git;protocol=ssh"
SRCREV_buv-runbmc := "6fe3d2677320c391aed5c6d61af38ed43b508e62"