FILESEXTRAPATHS:prepend:buv-runbmc := "${THISDIR}/linux-nuvoton:"

SRC_URI:append:buv-runbmc = " file://buv-runbmc.cfg"
