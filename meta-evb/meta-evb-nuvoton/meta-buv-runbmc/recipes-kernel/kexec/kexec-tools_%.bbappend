FILESEXTRAPATHS:prepend:buv-runbmc := "${THISDIR}/${PN}:"

