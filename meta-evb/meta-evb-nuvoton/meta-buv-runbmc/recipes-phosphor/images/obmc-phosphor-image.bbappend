inherit buv-image

