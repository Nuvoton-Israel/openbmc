PACKAGECONFIG:append:evb-npcm845 = " nic-ethtool"
PACKAGECONFIG:append:evb-npcm845 = " uboot-env"
PACKAGECONFIG:remove:evb-npcm845 = "default-link-local-autoconf"
