# this patch is used to avoid access uboot envoronment
RDEPENDS:${PN}-devtools:remove:scm-npcm845 = "trace-enable"
