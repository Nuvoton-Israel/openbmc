PACKAGECONFIG:append = " log-watchdog log-threshold"
