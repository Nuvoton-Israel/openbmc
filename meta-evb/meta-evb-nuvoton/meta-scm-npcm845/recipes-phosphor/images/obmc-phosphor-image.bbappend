IMAGE_INSTALL:append = " tpm2-tools tpm2-tss libtss2 libtss2-mu libtss2-tcti-device tpm2-abrmd"
IMAGE_INSTALL:append:m1120-c2195 = " program-edid htop"
