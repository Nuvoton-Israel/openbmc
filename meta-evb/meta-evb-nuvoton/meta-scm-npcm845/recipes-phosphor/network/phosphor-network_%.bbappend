PACKAGECONFIG:append:scm-npcm845 = " nic-ethtool"
PACKAGECONFIG:append:scm-npcm845 = " uboot-env"
PACKAGECONFIG:remove:scm-npcm845 = "default-link-local-autoconf"
