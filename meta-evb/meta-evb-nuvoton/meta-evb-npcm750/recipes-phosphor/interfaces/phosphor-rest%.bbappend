FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-add-kvm-handler.patch"
SRC_URI += "file://0002-add-vm-handler.patch"