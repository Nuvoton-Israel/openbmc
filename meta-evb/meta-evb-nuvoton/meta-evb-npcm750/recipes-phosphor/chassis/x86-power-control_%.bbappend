FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-power-control-WAR-pull-up-for-1.patch"
SRC_URI += "file://0001-meta-evb-npcm750-x86-power-control-add-gpio-config-f.patch"
