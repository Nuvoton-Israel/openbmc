FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-meta-evb-npcm750-op-pwrctl-modify-power-pin-control.patch"
