FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-all-buttons-gpio-control-by-json-method.patch"
