FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


SRC_URI += "file://0001-obmc-mgt-system-WAR-support-nuvoton-gpio.patch"

