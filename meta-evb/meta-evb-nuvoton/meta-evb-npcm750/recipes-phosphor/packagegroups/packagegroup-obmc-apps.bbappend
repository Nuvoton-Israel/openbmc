RDEPENDS_${PN}-extras_remove = " \
       bmcweb \
       "
RDEPENDS_${PN}-extras += " \
       phosphor-rest \
       phosphor-gevent \
       "
