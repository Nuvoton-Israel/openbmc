FILESEXTRAPATHS_prepend_evb-npcm750 := "${THISDIR}/${PN}:"

SRC_URI_append_evb-npcm750 = " file://sol-default.override.yml"
