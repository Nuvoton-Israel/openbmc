FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-meta-evb-npcm750-phosphor-state-manager-fix-chassis-.patch \
            "