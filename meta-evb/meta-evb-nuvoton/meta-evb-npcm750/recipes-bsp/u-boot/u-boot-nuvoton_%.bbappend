FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "5d036755c2e13b5244f63ce052657e4ef3089bd5"

SRC_URI += "file://0001-libfdt-fix-libfdt-header-conflicts-between-UBoot-and.patch"
