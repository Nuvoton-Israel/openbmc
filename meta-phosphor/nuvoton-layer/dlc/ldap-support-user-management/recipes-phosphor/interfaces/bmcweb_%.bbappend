
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


SRC_URI += "file://0001-meta-evb-npcm750-add-bmcweb-login-from-ldap-with-Nuv.patch \
			"

