
FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ldap-config-patch-for-automation-test.patch"
