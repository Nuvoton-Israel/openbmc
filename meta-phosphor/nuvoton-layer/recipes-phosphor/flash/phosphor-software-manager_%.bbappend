PACKAGECONFIG_nuvoton += " verify_signature"
