PACKAGECONFIG = "jpeg lzo systemd zlib openssl pthread"
INSANE_SKIP:${PN}-dev += "buildpaths"
