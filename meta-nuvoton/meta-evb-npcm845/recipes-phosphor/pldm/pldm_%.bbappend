EXTRA_OEMESON:append = " -Dtransport-implementation=af-mctp"
EXTRA_OEMESON:append = " -Dmaximum-transfer-size=246"
