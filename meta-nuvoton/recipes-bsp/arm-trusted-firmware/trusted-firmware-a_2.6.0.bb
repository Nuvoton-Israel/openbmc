SRCREV = "69e6d531f055bd6328d529b6f797b548c2c00aa1"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"

include trusted-firmware-a.inc
