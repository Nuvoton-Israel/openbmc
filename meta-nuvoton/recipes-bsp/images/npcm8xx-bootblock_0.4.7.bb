SRCREV = "4bee6bd07772b53697ba5f9771855ef359529224"

require npcm8xx-bootblock.inc
