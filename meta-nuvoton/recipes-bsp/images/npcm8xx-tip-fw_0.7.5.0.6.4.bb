SRCREV = "60c6282d838127ab3632a772f2e6744fe9b708fe"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
