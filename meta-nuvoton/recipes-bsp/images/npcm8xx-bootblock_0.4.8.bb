SRCREV = "b42684013eca57f7b4599a5da04d6b8792f20c85"

require npcm8xx-bootblock.inc
