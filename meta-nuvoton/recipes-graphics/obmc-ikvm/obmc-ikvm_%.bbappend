LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm"
SRCREV:nuvoton := "931e11f4cef523757a45b9d12e8689dc5241bc22"

#LIC_FILES_CHKSUM = "file://LICENSE;md5=75859989545e37968a99b631ef42722e"
#SRC_URI_nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm;branch=upstream-v4l2"
#SRCREV_nuvoton := "fd145077fa35cd11906d7016368c77710b7f76f7"
