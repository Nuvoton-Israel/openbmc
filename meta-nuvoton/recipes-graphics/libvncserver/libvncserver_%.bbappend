PACKAGECONFIG:append:nuvoton = " ipv6"
