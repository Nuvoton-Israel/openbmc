SRCREV_tfa = "753da8ce4500b1084be41a1d3bb034d47cdf2add"
LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b5fbfdeb6855162dded31fadcd5d4dc5"
